# Keil uVision project os.uvprojx, settings and files
target STM32F103ZE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: os +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\user;.\os;.\RTE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c
  group Os
    ./os/: task.c task.s os.c critical_section.c critical_section.s memory.c io.c
  group Drivers
    ./drivers/: LED.c usart.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
